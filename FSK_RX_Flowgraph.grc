<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Joshua Mack, Ezra Muir</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>ECE531 Project - FSK Receiver</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lo_freq</value></param>
<param><key>value</key><value>313.85e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>300e6</value></param>
<param><key>step</key><value>1e3</value></param>
<param><key>stop</key><value>500e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>loop_bw</value></param>
<param><key>value</key><value>0.01*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lpf_cutoff_freq</value></param>
<param><key>value</key><value>150e3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>25e3</value></param>
<param><key>step</key><value>5e3</value></param>
<param><key>stop</key><value>300e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>lpf_decim</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>lpf_transition_width</value></param>
<param><key>value</key><value>20e3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>5e3</value></param>
<param><key>step</key><value>5e3</value></param>
<param><key>stop</key><value>100e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_bw</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>50e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>40e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>stop</key><value>50e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_per_symbol</value></param>
<param><key>value</key><value>4700/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>squelch_cutoff</value></param>
<param><key>value</key><value>-7</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>0</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1000</value></param>
</block>
<block>
<key>analog_simple_squelch_cc</key>
<param><key>id</key><value>analog_simple_squelch_cc_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>squelch_cutoff</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/gnuradio/ece531-project/data_files/civic_unlock_presses_40msps_30khz.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>length</key><value>int(419.8/2)</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_peak_detector2_fb</key>
<param><key>id</key><value>blocks_peak_detector2_fb_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>look_ahead</key><value>1000</value></param>
<param><key>threshold_factor_rise</key><value>1</value></param>
</block>
<block>
<key>blocks_tcp_server_sink</key>
<param><key>id</key><value>blocks_tcp_server_sink_1</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>12345</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>noblock</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fosphor_qt_sink_c</key>
<param><key>id</key><value>fosphor_qt_sink_c_0</value></param>
<param><key>freq_center</key><value>lo_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_span</key><value>samp_rate</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>lpf_cutoff_freq</value></param>
<param><key>decim</key><value>lpf_decim</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>lpf_transition_width</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>lo_freq</value></param>
<param><key>manual_gain</key><value>64.0</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>rf_bw</value></param>
<param><key>samplerate</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>int(1e6)/lpf_decim</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>100</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_NORM</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>int(1e6)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>int(1e6)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_2</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>int(1e4)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>1</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_simple_squelch_cc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_peak_detector2_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>blocks_tcp_server_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_peak_detector2_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>fosphor_qt_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>analog_simple_squelch_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
